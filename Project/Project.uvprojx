# Keil uVision project Project.uvprojx, settings and files
target Cat_GNSS_IoT (ARM-ADS)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Cat_GNSS_IoT
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STM32F4_DISCO
  c misc: --C99
  c include: .\Src;..\Drivers\CMSIS\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Middlewares\segger_rtt;..\Drivers\BSP;..\Utilities\trace;..\Middlewares\Third_Party\FatFs\src;..\Middlewares\Third_Party\FatFs\src\drivers;..\Middlewares\mqtt\MQTTPacket;..\Middlewares\mqtt;..\Utilities\iot;..\FreeRTOS\include;..\FreeRTOS\CMSIS_RTOS;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\Middlewares\tcp;..\Gizwits\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c
  group Doc
    ../: readme.txt
  group User
    ./Src/: error_handler.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_hal_timebase_tim.c iot_platform.c tcp_task.c nmealib.c nmeautil.c
  group Drivers/CMSIS
    ./Src/: system_stm32f4xx.c
  group Drivers/BSP
    ../Drivers/BSP/: uart4.c lm61.c uart6.c rcc.c sys.c uart5.c
  group Utilities/trace
    ../Utilities/trace/: trace.c
  group Utilities/iot
    ../Utilities/iot/: iot_list.c iot_timer.c iot_device.c
  group FreeRTOS/Portable
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_2.c
  group FreeRTOS
    ../FreeRTOS/: list.c queue.c tasks.c timers.c croutine.c event_groups.c
  group FreeRTOS/CMSIS_RTOS
    ../FreeRTOS/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/tcp
    ../Middlewares/tcp/: TCPClient.c
  group Gizwits
    ../Gizwits/src/: tool.c libemqtt.c cloud.c aes.c aesdata.c
software components: CMSIS:CORE 3.40.0
